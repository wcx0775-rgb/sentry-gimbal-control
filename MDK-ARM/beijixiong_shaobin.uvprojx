# Keil uVision project beijixiong_shaobin.uvprojx, settings and files
target beijixiong_shaobin (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: beijixiong_shaobin.elf +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../application/typedef;../boards;../components/controller;../application/chassis;../application/other;../application/robot_cmd;../application/assist;../application/robot_param;../components/algorithm;../components/algorithm/Include;../application/IMU;../components/support;../components/devices;../application/shoot;../application/VOFA;../application/gimbal;../application/music;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../application/communication
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c crc.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group boards
    ../boards/: bsp_can.c bsp_can.h bsp_rc.c bsp_rc.h bsp_delay.c bsp_delay.h bsp_usart.c bsp_usart.h bsp_imu_pwm.c bsp_imu_pwm.h bsp_spi.c bsp_spi.h bsp_buzzer.c bsp_buzzer.h bsp_led.c bsp_led.h
  group controller
    ../components/controller/: pid.c pid.h LQR.c LQR.h
  group other
    ../application/other/: remote_control.c remote_control.h led_flow_task.c led_flow_task.h
  group robot_cmd
    ../application/robot_cmd/: CAN_cmd_damiao.c CAN_cmd_damiao.h CAN_cmd_dji.c CAN_cmd_dji.h CAN_receive.c CAN_receive.h motor.c motor.h SupCap.c SupCap.h CAN_communication.c CAN_communication.h CAN_cmd_gaoqing.c CAN_cmd_gaoqing.h
  group assist
    ../application/assist/: detect_task.c detect_task.h data_exchange.c data_exchange.h
  group algorithm
    ../components/algorithm/: arm_cortexM4lf_math.lib user_lib.c AHRS.h AHRS.lib AHRS_middleware.c AHRS_middleware.h
  group IMU
    ../application/IMU/: IMU.h IMU_solve.c IMU_solve.h IMU_task.c IMU_task.h
  group support
    ../components/support/: clist.c clist.h men_mang4.c mem_mang4.h macro_mutex.h kalman_filter.c kalman_filter.h fifo.c fifo.h CRC8_CRC16.c CRC8_CRC16.h signal_generator.c signal_generator.h
  group devices
    ../components/devices/: BMI088driver.c BMI088driver.h BMI088Middleware.c BMI088Middleware.h BMI088reg.h ist8310driver.c ist8310driver.h ist8310driver_middleware.c ist8310driver_middleware.h
  group shoot
    ../application/shoot/: shoot_fric_trigger.c shoot_fric_tirgger.h shoot_task.c shoot_task.h
  group VOFA
    ../application/VOFA/: VOFA.c VOFA.h
  group gimbal
    ../application/gimbal/: gimbal_yaw_pitch_direct.c gimbal_yaw_pitch_direct.h gimbal.c gimbal.h gimbal_task.c gimbal_task.h
  group music
    ../application/music/: music_error.c music_error.h music_motor_offline.c music_motor_offline.h music_rc_offline.c music_rc_offline.h music_referee.c music_referee.h music_start.c music_start.h music_typedef.h music_task.c music_task.h music_hao_yun_lai.c music_hao_yun_lai.h music_gong_xi_fa_cai.c music_gong_xi_fa_cai.h
  group communicate
    ../application/communication/: usb_debug.h usb_task.c usb_task.h
software components: CMSIS:CORE 4.3.0
